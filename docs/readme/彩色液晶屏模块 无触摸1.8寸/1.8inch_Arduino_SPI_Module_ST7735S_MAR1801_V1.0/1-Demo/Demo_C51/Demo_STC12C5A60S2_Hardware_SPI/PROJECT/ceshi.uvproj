# Keil uVision project ceshi.uvproj, settings and files
target QD-TFT (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: ceshi +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\font;..\GUI;..\LCD;..\sys;..\touch;..\USER
  group USER
    ../USER/: main.c test.c
    ../GUI/: gui.c
  group SYSTEM
    ../sys/: STARTUP.A51 sys.c
  group HARDWARE
    ../touch/: touch.c
    ../LCD/: LCD.c
